# IAR project LY-STM8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\lib; ..\usr; ..\bsp; ..\iar
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LY-STM8.hex
  ILINK.IlinkOutputFile: LY-STM8.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/: at24cxx.c i2c.c led.c tim1_pwm.c tm1650.c uart1.c
  group LIB
    ../LIB/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c
    ../LIB/: stm8s_conf.h
  group USR
    ../USR/: main.c pbdata.c pbdata.h stm8s_it.c
