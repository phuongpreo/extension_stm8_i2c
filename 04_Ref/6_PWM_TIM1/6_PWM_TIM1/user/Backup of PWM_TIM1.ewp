# IAR project Backup of PWM_TIM1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ../../6_PWM_TIM1\lib\inc; ../../6_PWM_TIM1\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_TIM1.s19
  ILINK.IlinkOutputFile: PWM_TIM1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c
  group user
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
